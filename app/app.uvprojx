# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08004000,0x0003C000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe --bin .\build\app\app.axf --output .\build\app\App.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ./core;./config;./modules/board;./modules/led;./modules/key;./modules/systick;./modules/bootapi;./libraries/cmsis/inc;./libraries/cmsis/system;./libraries/stdperiph/inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x08004000 size 0x0003C000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    core/: main.c stm32f4xx_it.c
  group Modules
    modules/led/: led.c
    modules/key/: key.c
    modules/systick/: systick.c
  group CMSIS
    libraries/cmsis/startup/: startup_stm32f40_41xxx.s
    libraries/cmsis/system/: system_stm32f4xx.c
  group StdPeriph
    libraries/stdperiph/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
