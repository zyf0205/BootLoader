# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x00004000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin .\build\bootloader\bootloader.axf --output .\build\bootloader\Bootloader.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ./core;./config;./drivers/usart;./drivers/flash;./drivers/crc32;./protocols/ymodem;./app;./modules/board;./modules/led;./modules/key;./modules/systick;./modules/bootapi;./libraries/cmsis/inc;./libraries/cmsis/system;./libraries/stdperiph/inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x00004000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    core/: main.c stm32f4xx_it.c
  group Drivers
    drivers/usart/: usart.c
    drivers/flash/: flash.c
    drivers/crc32/: crc32.c
  group Protocols
    protocols/ymodem/: ymodem.c crc16.c
  group App
    app/: boot.c updater.c
  group Modules
    modules/led/: led.c
    modules/key/: key.c
    modules/systick/: systick.c
  group CMSIS
    libraries/cmsis/startup/: startup_stm32f40_41xxx.s
    libraries/cmsis/system/: system_stm32f4xx.c
  group StdPeriph
    libraries/stdperiph/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_dma.c
